# Keil uVision project HHD1705_Full_Lib_V2.0.uvprojx, settings and files
target HHD32F107 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: HHD32F107
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORTEX_M3
  c include: ..\User;..\HHD32F1xx_library\Drivers\include;..\HHD32F1xx_library\Core\CM3\DeviceSupport\HHD32F1xx;..\HHD32F1xx_library\Core\CM3\CoreSupport;..\HHD32F1xx_library\ETH_Driver\inc;..\lib;.\RTE\RTOS;..\RTT\include;..\middleware\lwip-1.3.2\src;..\middleware\lwip-1.3.2\src\include;..\middleware\lwip-1.3.2\src\arch\include;..\middleware\lwip-1.3.2\src\netif;..\middleware\lwip-1.3.2\src\include\ipv4;..\RTT\include\armlibc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/: system_HHD32F1xx.c
    ../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/Startup/rvds/: startup_HHD32F1xx_s.s
  group APP
    ../User/: hhd32f107.c hhd32f10x_it.c simulator_spi.c MT25Q.c FPGA_Manager.c main.c load_server_BSD.c
    ../lib/: netconf.c
  group DRIVER
    ../User/: IO_Init.c
    ../HHD32F1xx_library/Drivers/source/: hhd_can.c hhd_gpio.c hhd_rcc.c hhd_sys.c hhd_uart.c
    ../HHD32F1xx_library/ETH_Driver/src/: hhd_eth.c
  group lib
    ./Objects/: HHD1705_XVC_lib.lib
  group RTT
    ./RTE/RTOS/: board.c rtconfig.h
    ../RTT/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c mem.c
    ../RTT/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group LWIP
    ../middleware/lwip-1.3.2/src/arch/: sys_arch.c sys_arch_init.c
    ../middleware/lwip-1.3.2/src/core/: init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../middleware/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../middleware/lwip-1.3.2/src/netif/: etharp.c ethernetif.c
    ../middleware/lwip-1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
