# Keil uVision project HHD1705_Demo_V2.0.uvprojx, settings and files
target Demo_V2.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: HHD1705_Demo_V2.0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\HHD32F1xx_library\Drivers\include;..\HHD32F1xx_library\Core\CM3\DeviceSupport\HHD32F1xx;..\HHD32F1xx_library\Core\CM3\CoreSupport;..\HHD32F1xx_library\ETH_Driver\inc;..\lib;.\RTE\RTOS;..\RTT\include;..\middleware\lwip-1.3.2\src;..\middleware\lwip-1.3.2\src\include;..\middleware\lwip-1.3.2\src\arch\include;..\middleware\lwip-1.3.2\src\netif;..\middleware\lwip-1.3.2\src\include\ipv4;..\RTT\include\armlibc;.\RTE\_HHD32F107
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group RTT
    ./RTE/RTOS/: board.c rtconfig.h
    ../RTT/libcpu/arm/cortex-m3/: context_rvds.S
  group SRC
    ../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/Startup/rvds/: startup_hhd32F1xx_s.s
    ../User/: hhd32f10x_it.c
  group APP
    ../User/: demo_main.c HHD1705_lib.h
  group LIB
    ./Objects/: HHD32F107.lib
