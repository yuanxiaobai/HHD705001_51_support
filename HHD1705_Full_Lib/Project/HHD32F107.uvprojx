# Keil uVision project HHD32F107.uvprojx, settings and files
target HHD32F107 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: HHD32F107 (library)
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORTEX_M3
  c include: ..\User;..\HHD32F1xx_library\Drivers\include;..\middleware\lwip-1.3.1\src\include;..\HHD32F1xx_library\Core\CM3\DeviceSupport\HHD32F1xx;..\middleware\lwip-1.3.1\port;..\middleware\lwip-1.3.1\src\include\ipv4;..\middleware\lwip-1.3.1\src\include\lwip;..\middleware\lwip-1.3.1\src\include\ipv4\lwip;..\HHD32F1xx_library\Core\CM3\CoreSupport;..\HHD32F1xx_library\ETH_Driver\inc;..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../HHD32F1xx_library/Core/CM3/CoreSupport/: core_cm3.c
    ../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/: system_HHD32F1xx.c
    ../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/Startup/rvds/: startup_HHD32F1xx_s.s
  group APP
    ../User/: netconf.c hhd32f107.c hhd32f10x_it.c load_server.c simulator_spi.c MT25Q.c start.c FPGA_Manager.c
  group DRIVER
    ../middleware/lwip-1.3.1/port/: ethernetif.c
    ../User/: IO_Init.c
    ../HHD32F1xx_library/Drivers/source/: hhd_adc.c hhd_dma.c hhd_can.c hhd_crc.c hhd_dac.c hhd_gpio.c hhd_rcc.c hhd_spi.c hhd_sys.c hhd_timer.c hhd_uart.c hhd_wdt.c
    ../HHD32F1xx_library/ETH_Driver/src/: hhd_eth.c
  group LWIP
    ../middleware/lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../middleware/lwip-1.3.1/src/core/: init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../middleware/lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../middleware/lwip-1.3.1/src/netif/: etharp.c
  group lib
    ../lib/: LIB_v1_0.lib
