# Keil uVision project HHD1705_Demo_Full.uvproj, settings and files
target HHD1705 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: HHD1705_Demo_Full
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORTEX_M3
  c include: ..\User;..\HHD32F1xx_library\Drivers\include;..\middleware\lwip-1.3.1\src\include;..\HHD32F1xx_library\Core\CM3\DeviceSupport\HHD32F1xx;..\middleware\lwip-1.3.1\port;..\middleware\lwip-1.3.1\src\include\ipv4;..\middleware\lwip-1.3.1\src\include\lwip;..\middleware\lwip-1.3.1\src\include\ipv4\lwip;..\HHD32F1xx_library\Core\CM3\CoreSupport;..\HHD32F1xx_library\ETH_Driver\inc;..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../User/: main.c
  group LIB
    ../lib/: HHD32F107.lib LIB_v1_0.lib
  group CMSIS
    ../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/Startup/rvds/: startup_hhd32F1xx_s.s
    ../User/: hhd32f10x_it.c
